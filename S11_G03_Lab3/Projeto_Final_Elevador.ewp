# IAR project Projeto_Final_Elevador.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; ARMCM4_FP; PART_TM4C1294NCPDT; UART_BUFFERED
  ICCARM.CCIncludePath2: src; ..\drivers; ..\driverlib; ..\TivaWare_C_Series-2.1.4.178; ..\..\..\; ..\; ..\driverlib; ..\Device\ARM\ARMCM4\Include; ..\CMSIS\RTOS2\Include; ..\CMSIS\RTOS2\RTX\Include; ..\CMSIS\RTOS2\RTX\Library\IAR\IDE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Projeto_Final_Elevador.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: driverleds.c elevadores_control.c mydelay.s Projeto_Final_Elevador.c RTX_Config.c rtx_lib.c startup_tm4c1294.s system_tm4c1294.c uart_control.c
    ../driverlib/ewarm/Exe/: driverlib.a
    ../CMSIS/RTOS2/RTX/Library/IAR/: RTX_CM4F.a
    ../../EK-TM4C1294_IAR8/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
